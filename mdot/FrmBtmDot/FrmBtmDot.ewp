# IAR project FrmBtmDot.ewp, settings and files
configuration FrmBtmDot (ARM, debug)
  General.OGChipSelectEditMenu: STM32F411RE ST STM32F411RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: -DDEVICE_RTC=1; --enable_restrict; -DTOOLCHAIN_object; -DARM_MATH_CM4; --guard_calls; --preinclude=mbed_config.h; -DUSE_PLL_HSE_EXTC=0; -DTARGET_STM32F4; -DDEVICE_SLEEP=1; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -DDEVICE_PWMOUT=1; -DTARGET_MTS_MDOT_F411RE; -DTARGET_RTOS_M4_M7; -DDEVICE_SPISLAVE=1; -DDEVICE_PORTOUT=1; -DDEVICE_STDIO_MESSAGES=1; -DTARGET_RELEASE; -DTARGET_LIKE_MBED; -DDEVICE_INTERRUPTIN=1; -DTARGET_M4; -DDEVICE_ANALOGIN=1; -DTARGET_LIKE_CORTEX_M4; -D__CORTEX_M4; -DMBED_BUILD_TIMESTAMP=1524572429.98; -DTARGET_CORTEX_M; -DDEVICE_SERIAL=1; -DDEVICE_I2C=1; -DTARGET_CORTEX; -DTARGET_STM; -DHSE_VALUE=26000000; -DTARGET_STM32F411RE; -DTARGET_UVISOR_UNSUPPORTED; -DDEVICE_I2C_ASYNCH=1; --no_wrap_diagnostics; -DVECT_TAB_OFFSET=0x00010000; -DTARGET_FAMILY_STM32; -DDEVICE_SPI=1; -D__MBED__=1; -DTOOLCHAIN_IAR; -DDEVICE_PORTIN=1; -D__FPU_PRESENT=1; -DDEVICE_I2CSLAVE=1; -D__CMSIS_RTOS; -DDEVICE_SPI_ASYNCH=1; -DTRANSACTION_QUEUE_SIZE_SPI=2; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: .; SX127x; mbed/.; mbed/TARGET_MTS_MDOT_F411RE; mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM; mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4; mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4/TARGET_MTS_MDOT_F411RE; mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4/TARGET_MTS_MDOT_F411RE/device; mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4/device; mbed/TARGET_MTS_MDOT_F411RE/TOOLCHAIN_IAR; mbed/drivers; mbed/hal; mbed/platform; 
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -DTRANSACTION_QUEUE_SIZE_SPI=2; -D__CORTEX_M4; -DARM_MATH_CM4; -D__FPU_PRESENT=1; -D__MBED_CMSIS_RTOS_CM; -DHSE_VALUE=26000000; -DVECT_TAB_OFFSET=0x00010000; -D__CMSIS_RTOS; -DUSE_PLL_HSE_EXTC=0
  OBJCOPY.OOCOutputFile: name.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_MTS_MDOT_F411RE/TOOLCHAIN_IAR/stm32f411xe.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group FrmBtmDot
    /tmp/tmpbeEu16/: mbed_config.h
    ./: main.cpp
  group mbed
    mbed/: mbed.h
    mbed/TARGET_MTS_MDOT_F411RE/: cmsis_armcc.h arm_math.h core_cmSecureAccess.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h tz_context.h
    mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/: PeripheralPins.h PinNamesTypes.h PortNames.h gpio_object.h mbed_rtx.h nvic_addr.h rtc_api_hal.h serial_api_hal.h stm32_assert.h
    mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4/: can_device.h common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h spi_device.h
    mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4/TARGET_MTS_MDOT_F411RE/: PeripheralNames.h PinNames.h objects.h
    mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4/TARGET_MTS_MDOT_F411RE/device/: cmsis_nvic.h cmsis.h stm32f411xe.h hal_tick.h system_stm32f4xx.h stm32f4xx.h
    mbed/TARGET_MTS_MDOT_F411RE/TARGET_STM/TARGET_STM32F4/device/: stm32f4xx_hal_adc_ex.h stm32_hal_legacy.h stm32f4xx_hal.h stm32f4xx_hal_adc.h stm32f4xx_hal_can_legacy.h stm32f4xx_hal_can.h stm32f4xx_hal_conf.h stm32f4xx_hal_cec.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_cortex.h stm32f4xx_hal_crc.h stm32f4xx_hal_cryp.h stm32f4xx_hal_cryp_ex.h stm32f4xx_hal_dac.h stm32f4xx_hal_dac_ex.h stm32f4xx_hal_dcmi.h stm32f4xx_hal_dcmi_ex.h stm32f4xx_hal_def.h stm32f4xx_hal_dfsdm.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma2d.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_dsi.h stm32f4xx_hal_eth.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_fmpi2c.h stm32f4xx_hal_fmpi2c_ex.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_hash.h stm32f4xx_hal_hash_ex.h stm32f4xx_hal_hcd.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_i2s.h stm32f4xx_hal_i2s_ex.h stm32f4xx_hal_irda.h stm32f4xx_hal_iwdg.h stm32f4xx_hal_lptim.h stm32f4xx_hal_ltdc.h stm32f4xx_hal_ltdc_ex.h stm32f4xx_hal_mmc.h stm32f4xx_hal_nand.h stm32f4xx_hal_nor.h stm32f4xx_hal_pccard.h stm32f4xx_hal_pcd.h stm32f4xx_hal_pcd_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_qspi.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_rtc.h stm32f4xx_hal_rtc_ex.h stm32f4xx_hal_sai.h stm32f4xx_hal_sai_ex.h stm32f4xx_hal_sd.h stm32f4xx_hal_sdram.h stm32f4xx_hal_smartcard.h stm32f4xx_hal_spdifrx.h stm32f4xx_hal_spi.h stm32f4xx_hal_sram.h stm32f4xx_hal_tim.h stm32f4xx_hal_tim_ex.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_hal_wwdg.h stm32f4xx_ll_adc.h stm32f4xx_ll_bus.h stm32f4xx_ll_cortex.h stm32f4xx_ll_crc.h stm32f4xx_ll_dac.h stm32f4xx_ll_dma.h stm32f4xx_ll_dma2d.h stm32f4xx_ll_exti.h stm32f4xx_ll_fmc.h stm32f4xx_ll_fsmc.h stm32f4xx_ll_gpio.h stm32f4xx_ll_i2c.h stm32f4xx_ll_iwdg.h stm32f4xx_ll_lptim.h stm32f4xx_ll_pwr.h stm32f4xx_ll_rcc.h stm32f4xx_ll_rng.h stm32f4xx_ll_rtc.h stm32f4xx_ll_sdmmc.h stm32f4xx_ll_spi.h stm32f4xx_ll_system.h stm32f4xx_ll_tim.h stm32f4xx_ll_usart.h stm32f4xx_ll_usb.h stm32f4xx_ll_utils.h stm32f4xx_ll_wwdg.h
    mbed/drivers/: DigitalInOut.h AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h SPI.h SPISlave.h Serial.h SerialBase.h SerialWireOutput.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: critical_section_api.h Driver_Common.h Driver_Storage.h analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h ethernet_api.h dma_api.h emac_api.h flash_data.h flash_api.h gpio_irq_api.h gpio_api.h lp_ticker_api.h i2c_api.h itm_api.h pwmout_api.h pinmap.h port_api.h serial_api.h rtc_api.h ticker_api.h sleep_api.h spi_api.h us_ticker_api.h trng_api.h
    mbed/platform/: CriticalSectionLock.h ATCmdParser.h CThunk.h CallChain.h Callback.h CircularBuffer.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h NonCopyable.h PlatformMutex.h ScopedLock.h SingletonPtr.h Stream.h Transaction.h critical.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h rtc_time.h semihost_api.h sleep.h toolchain.h wait_api.h
    mbed/TARGET_MTS_MDOT_F411RE/TOOLCHAIN_IAR/: startup_stm32f411xe.o PeripheralPins.o analogin_api.o analogin_device.o analogout_api.o analogout_device.o can_api.o cmain.o flash_api.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_init_pre.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed_board.o mbed_overrides.o mbed_retarget.o mbed_sdk_boot.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o serial_device.o sleep.o spi_api.o stm32f4xx_hal_adc_ex.o stm32f4xx_hal.o stm32f4xx_hal_adc.o stm32f4xx_hal_can_legacy.o stm32f4xx_hal_can.o stm32f4xx_hal_cortex.o stm32f4xx_hal_cec.o stm32f4xx_hal_cryp.o stm32f4xx_hal_crc.o stm32f4xx_hal_flash_ramfunc.o stm32f4xx_hal_cryp_ex.o stm32f4xx_hal_dac.o stm32f4xx_hal_dac_ex.o stm32f4xx_hal_dcmi.o stm32f4xx_hal_dcmi_ex.o stm32f4xx_hal_dfsdm.o stm32f4xx_hal_dma.o stm32f4xx_hal_dma2d.o stm32f4xx_hal_dma_ex.o stm32f4xx_hal_dsi.o stm32f4xx_hal_eth.o stm32f4xx_hal_flash.o stm32f4xx_hal_flash_ex.o stm32f4xx_hal_fmpi2c.o stm32f4xx_hal_fmpi2c_ex.o stm32f4xx_hal_gpio.o stm32f4xx_hal_hash.o stm32f4xx_hal_hash_ex.o stm32f4xx_hal_hcd.o stm32f4xx_hal_i2c.o stm32f4xx_hal_i2c_ex.o stm32f4xx_hal_i2s.o stm32f4xx_hal_i2s_ex.o stm32f4xx_hal_irda.o stm32f4xx_hal_iwdg.o stm32f4xx_hal_lptim.o stm32f4xx_hal_ltdc.o stm32f4xx_hal_ltdc_ex.o stm32f4xx_hal_mmc.o stm32f4xx_hal_nand.o stm32f4xx_hal_nor.o stm32f4xx_hal_pccard.o stm32f4xx_hal_pcd.o stm32f4xx_hal_pcd_ex.o stm32f4xx_hal_pwr.o stm32f4xx_hal_pwr_ex.o stm32f4xx_hal_qspi.o stm32f4xx_hal_rcc.o stm32f4xx_hal_rcc_ex.o stm32f4xx_hal_rng.o stm32f4xx_hal_rtc.o stm32f4xx_hal_rtc_ex.o stm32f4xx_hal_sai.o stm32f4xx_hal_sai_ex.o stm32f4xx_hal_sd.o stm32f4xx_hal_sdram.o stm32f4xx_hal_smartcard.o stm32f4xx_hal_spdifrx.o stm32f4xx_hal_spi.o stm32f4xx_hal_sram.o stm32f4xx_hal_tim.o stm32f4xx_hal_tim_ex.o stm32f4xx_hal_uart.o stm32f4xx_hal_usart.o stm32f4xx_hal_wwdg.o stm32f4xx_ll_adc.o stm32f4xx_ll_crc.o stm32f4xx_ll_dac.o stm32f4xx_ll_dma.o stm32f4xx_ll_dma2d.o stm32f4xx_ll_exti.o stm32f4xx_ll_fmc.o stm32f4xx_ll_fsmc.o stm32f4xx_ll_gpio.o stm32f4xx_ll_i2c.o stm32f4xx_ll_lptim.o stm32f4xx_ll_pwr.o stm32f4xx_ll_rcc.o stm32f4xx_ll_rng.o stm32f4xx_ll_rtc.o stm32f4xx_ll_sdmmc.o stm32f4xx_ll_spi.o stm32f4xx_ll_tim.o stm32f4xx_ll_usart.o stm32f4xx_ll_usb.o stm32f4xx_ll_utils.o stm_spi_api.o system_clock.o system_stm32f4xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o mbed.a
  group SX127x
    SX127x/: sx127x.h sx127x_fsk.h sx127x_lora.h sx127x_fsk.cpp sx127x_lora.cpp sx127x.cpp
